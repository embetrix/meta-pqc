#enable openssl in libcurl
PACKAGECONFIG:append = " openssl"
